# Keil uVision project ProjectA.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ProjectA
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F030x8
  c include: .\inc;..\core\driver\hal\Inc;..\core\os\FreeRTOS\Source\include;..\core\driver\cmsis\device\STM32F0xx\Include;..\core\os\FreeRTOS\Source\CMSIS_RTOS;..\core\os\FreeRTOS\Source\portable\Keil\ARM_CM0;..\core\driver\cmsis\inc
  asm include: ..\project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ./: startup_stm32f030x8.s
  group FreeRTOS
    ../core/os/FreeRTOS/Source/portable/Keil/ARM_CM0/: port.c
    ../core/os/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../core/os/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Main
    ./src/: main.c
  group HAL
    ../core/driver/hal/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group CMSIS
    ./src/: system_stm32f0xx.c
